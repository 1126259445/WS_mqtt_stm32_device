# Keil uVision project F4_prj.uvprojx, settings and files
target F4_HD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F4_prj +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__TARGET_FPU_VFP,__CC_ARM,LWIP_DEBUG,USE_USB_OTG_FS
  c include: .\Source\Application;.\Source\cJOSN;.\Source\Library\inc;.\Source\Library\CORE;.\Source\Application\USER;.\Source\Drivers;.\Source\FreeRTOS\include;.\Source\FreeRTOS\portable\MemMang;.\Source\FreeRTOS\portable\RVDS\ARM_CM4F;.\Source\USB\STM32_USB_Device_Library\Class\cdc\inc;.\Source\USB\STM32_USB_Device_Library\Core\inc;.\Source\USB\STM32_USB_OTG_Driver\inc;.\Source\USB\USB-APP;.\Source\lwip-2.1.0\src\include;.\Source\SEGGER_RTT_V644\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applaction
    ./Source/Application/USER/: stm32f4xx_it.c system_stm32f4xx.c
    ./Source/Application/: main.c comm.c net_task.c mqtt_client.c monitor.c data_process.c
  group Drivers
    ./Source/Drivers/: usart.c tick.c enc28j60.c spi.c watchdog.c
  group FreeRTOS
    ./Source/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./Source/FreeRTOS/portable/MemMang/: heap_4.c
    ./Source/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Library
    ./Source/Library/src/: stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c misc.c
  group cJOSN
    ./Source/cJOSN/: cJSON.c
  group START
    ./Source/Library/CORE/: startup_stm32f40_41xxx.s
  group LWIP_API
    ./Source/lwip-2.1.0/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP_CORE
    ./Source/lwip-2.1.0/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ./Source/lwip-2.1.0/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group LWIP_NETIF
    ./Source/lwip-2.1.0/src/netif/: ethernet.c ethernetif.c
  group LWIP_APP
    ./Source/lwip-2.1.0/src/apps/mqtt/: mqtt.c
  group USB-Ddevece
    ./Source/USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ./Source/USB/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB-OTG
    ./Source/USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB-APP
    ./Source/USB/USB-APP/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group SEGGER_RTT_V644
    ./Source/SEGGER_RTT_V644/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ./Source/SEGGER_RTT_V644/Syscalls/: SEGGER_RTT_Syscalls_KEIL.c
